Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-04-25T10:45:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 25 10:45:27 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{1FDB3590-5A29-4378-A8E2-5304184F19D6}\ifc * Database version: 5507 * Database creation date: Thu Apr 25 10:45:26 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 25 10:45:27 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 25 10:45:27 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth, 64421109:64421109 Washbasin faucet, low pressure, 12 V, Bluetooth:351751
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 112 mm
Type - Electrical Engineering(Type) - Operating Voltage: 12 V
Type - Electrical(Type) - Bluetooth: 4.x; Electrical Connection: 9 / 12 VDC; Electronic Parts: Autofocus sensor;Low battery indication
Type - General(Type) - Author: Convergo AB; BIMObjectName: 64421109; ConvergoRefNr: 0087-1905-0033-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_87_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_30_96_07; Version: 1; VersionDate: 10/04/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 4057304008634; EMC Directive: EN 15091; EN Standard: EN 15091; Noise Class: I (ISO 3822); Protection Class: IP 55
Type - Identity Data(Type) - Catalog Drawing URL: http://static.hansa.com/catdrw/64421109; Class: Touchless, low pressure, Bluetooth®; Dimension Drawing URL: http://static.hansa.com/dimdrw/64421109; FDV Document URL: http://www.hansa.com/datasheet/64421109/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/64421109; Group: Washbasin faucets; Manufacturer: Hansa; Market: AUT;BEL;DEU;ESP;FRA;INT; Model: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; Name_en: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 370 x 192 x 90; Package Weight: 2.097 kg; Product Code: 64421109; Product Datasheet: http://www.hansa.com/datasheet/64421109/en; Product Family: HANSAELECTRA; Product Image URL: http://static.hansa.com/image/64421109; Product URL: http://static.hansa.com/64421109; Type Name: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; Usage Group: Offices, personnel sanitary facilities;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Kindergartens;Institutional kitchens;Hospitals;Food industry;Gas stations;Schools;Households;Airports, Railway stations;Sports stadiums;Hotels, Restaurants, Café
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation;Adjustable settings (via bluetooth);Without draw-rod opening; Aerator: Burglarproof; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection Size: G3/8; DN Size: DN15; Extensions: No pop-up waste included; Flow Rate At 300kPa: 0.00353147 m3/s; Installation and Maintenance: http://static.hansa.com/manual/64421109; Installation Type: Deck mounted; Intelligent After Flow Period: ON (OFF/ON); Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 300000 Pa; Recognition Range: optimally preset; Spare Parts: http://static.hansa.com/sp/64421109; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Bathroom, public & semi-public; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 64421109; Features: Touchless, low pressure, Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 64421109; Name: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 70x165x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Health Sales Arguments: Low pressure mixer - for appropriately equipped systems.; Technology Sales Arguments: Touch-free operation. Maximum comfort, maximum hygiene.
Pset_ManufacturerTypeInformation - ModelReference: 64421109; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0523307 m2; Volume: 0.00197725 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 64421109: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; Family and Type: 64421109: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 64421109: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; Type Id: 64421109: 64421109 Washbasin faucet, low pressure, 12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
